# Keil uVision project timer1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: timer1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\USER;..\PWM;..\UATR
  asm include: ..\USER;..\PWM
  group Source Group 1
    ./: main.c
    ../PWM/: pwm.c
    ../UATR/: Uart.c
